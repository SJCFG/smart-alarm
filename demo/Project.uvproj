# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source Group 1
    ./: main.c LCD1602.c LCD1602.h DS1302.c DS1302.h Timer.c Timer.h Delay.c Delay.h Buzzer.c Buzzer.h UART.c UART.h Key.c Key.h AT24C02.c AT24C02.h I2C.c I2C.h DHT11.c DHT11.h
